* Component: /home/ece_lab/mentor/ECE4500/HW2/HW2  Viewpoint: eldonet
.INCLUDE /home/ece_lab/mentor/ECE4500/HW2/HW2/eldonet/HW2_eldonet.spi
.INCLUDE /home/ece_lab/mentor/mgc/mit_0.25.lib
.OPTION NOASCII
.OPTION MODWL
.OPTION ENGNOT
.OPTION AEX

* --- Singles

* - Analysis Setup - DC
<<<<<<< HEAD
.DC V2 0 2.5 0.00001
=======
<<<<<<< HEAD
.DC V2 0 2.5 0.00001
=======
.DC V2 2.5 0 -0.1
>>>>>>> 559099fafff1d2d3bda55f28cce54ae15be693ac
>>>>>>> eba9bbe16f1a19bb044a525d797ef239c37b2ce1

* --- Waveform Outputs
.PROBE DC V(IN) V(OUT)

* --- Params
.TEMP 27

* --- Forces

* --- Libsetup
