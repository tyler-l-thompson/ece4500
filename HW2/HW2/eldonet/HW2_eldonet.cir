* Component: /home/ece_lab/mentor/ECE4500/HW2/HW2  Viewpoint: eldonet
.INCLUDE /home/ece_lab/mentor/ECE4500/HW2/HW2/eldonet/HW2_eldonet.spi
.INCLUDE /home/ece_lab/mentor/mgc/mit_0.25.lib
.OPTION NOASCII
.OPTION MODWL
.OPTION ENGNOT
.OPTION AEX

* --- Singles

* - Analysis Setup - DC
.DC V2 2.5 0 -0.1

* --- Waveform Outputs
.PROBE DC V(IN) V(OUT)

* --- Params
.TEMP 27

* --- Forces

* --- Libsetup
