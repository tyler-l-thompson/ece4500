* Component: /home/ece_lab/mentor/ECE4500/Project1/four_bit_alu/four_bit_alu  Viewpoint: eldonet
.INCLUDE /home/ece_lab/mentor/ECE4500/Project1/four_bit_alu/four_bit_alu/eldonet/four_bit_alu_eldonet.spi
.INCLUDE /home/ece_lab/mentor/mgc/mit_0.25.lib
.OPTION NOASCII
.OPTION MODWL
.OPTION ENGNOT
.OPTION AEX

* --- Singles

* - Analysis Setup - DC
.DC V2 0 2.5 0.0001

* --- Waveform Outputs
.PROBE DC V(A0) V(A1) V(A2) V(A3) V(B0) V(B1) V(B2) V(B3) V(BIN_CIN)
+ V(BOUT_COUT) V(CC0) V(CC1) V(CC2) V(CC3) V(F0) V(F1) V(F2) V(F3) V(OVF) V(S)
+ V(Z)
.PROBE DC V(SHIFT_OVF)
.PROBE DC V(ADD_OVF)
.PROBE DC V(OVF_SEL0) V(OVF_SEL1)
.PROBE DC V(COUT_1)
.PROBE DC V(COUT_0)
.PROBE DC V(PRE_F_0)
.PROBE DC V(ADD)
.PROBE DC V(A_XOR_B_0)
.PROBE DC V(COUT_2)
.PROBE DC V(A_XOR_B_2)
.PROBE DC V(SHIFT_C_OUT)

* --- Params
.TEMP 27

* --- Forces
VFORCE__A0_26 A0 VSS pattern 2.5 0 0 1e-12 1e-12 1e-07 1 R
VFORCE__A0_27 A1 VSS pattern 2.5 0 0 1e-12 1e-12 1e-07 1 R
VFORCE__A0_28 A2 VSS pattern 2.5 0 0 1e-12 1e-12 1e-07 1 R
VFORCE__A0_29 A3 VSS pattern 2.5 0 0 1e-12 1e-12 1e-07 1 R
VFORCE__A0_30 B0 VSS pattern 2.5 0 0 1e-12 1e-12 1e-07 0 R
VFORCE__A0_31 B1 VSS pattern 2.5 0 0 1e-12 1e-12 1e-07 0 R
VFORCE__A0_32 B2 VSS pattern 2.5 0 0 1e-12 1e-12 1e-07 0 R
VFORCE__A0_33 B3 VSS pattern 2.5 0 0 1e-12 1e-12 1e-07 0 R
VFORCE__A0_34 CC0 VSS pattern 2.5 0 0 1e-12 1e-12 1e-07 1 R
VFORCE__A0_35 CC1 VSS pattern 2.5 0 0 1e-12 1e-12 1e-07 0 R
VFORCE__A0_36 CC2 VSS pattern 2.5 0 0 1e-12 1e-12 1e-07 1 R
VFORCE__A0_37 CC3 VSS pattern 2.5 0 0 1e-12 1e-12 1e-07 1 R

* --- Libsetup
